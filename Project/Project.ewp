# IAR project Project.ewp, settings and files
configuration STM8S208 (STM8, debug)
  General.GenDeviceSelectMenu: STM8S208MB STM8S208MB
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: USE_STM8_128_EVAL; STM8S208
  ICCSTM8.CCIncludePath2: ..; ..\..\..\Libraries\STM8S_StdPeriph_Driver\inc; ..\..\..\Utilities\STM8S_EVAL; ..\..\..\Utilities\STM8S_EVAL\STM8S-128_EVAL; ..\..\..\Utilities\STM8S_EVAL\Common
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM8S207 (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S207MB STM8S207MB
  ICCSTM8.CCDefines: USE_STM8_128_EVAL; STM8S207
configuration STM8S105 (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S105K6 STM8S105K6
  ICCSTM8.CCDefines: STM8S105; USE_STDPERIPH_DRIVER
  ICCSTM8.CCIncludePath2: ..; ..\..\..\Libraries\STM8S_StdPeriph_Driver\inc; ..\..\..\Project\SmartBicycleLight\Main; ..\..\..\Project\SmartBicycleLight\App; ..\..\..\Project\SmartBicycleLight\Hal\inc; ..\..\..\Project\SmartBicycleLight\Hal\src
  OBJCOPY.OOCOutputFile: dimmer.hex
configuration STM8S103 (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: ..; ..\..\..\Libraries\STM8S_StdPeriph_Driver\inc
configuration STM8S903 (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S903K3 STM8S903K3
  ICCSTM8.CCDefines: STM8S903
  ICCSTM8.CCIncludePath2: as above
configuration STM8AF52Ax (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8AF52AA STM8AF52AA
  ICCSTM8.CCDefines: USE_STM8_128_EVAL; STM8AF52Ax
configuration STM8AF62Ax (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8AF62AA STM8AF62AA
  ICCSTM8.CCDefines: USE_STM8_128_EVAL; STM8AF62Ax
configuration STM8AF626x (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8AF6269 STM8AF6269
  ICCSTM8.CCDefines: STM8AF626x
  ICCSTM8.CCIncludePath2: as above
configuration STM8AF622x (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8AF6226 STM8AF6226
  ICCSTM8.CCDefines: STM8AF622x
  ICCSTM8.CCIncludePath2: as above
configuration STM8S001 (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S001J3 STM8S001J3
  ICCSTM8.CCDefines: STM8S001
  ICCSTM8.CCIncludePath2: as above
configuration STM8S003 (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S003K3 STM8S003K3
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: as above
configuration STM8S005 (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S005C6 STM8S005C6
  ICCSTM8.CCDefines: STM8S005
  ICCSTM8.CCIncludePath2: as above
configuration STM8S007 (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S007C8 STM8S007C8
  ICCSTM8.CCDefines: STM8S007
  ICCSTM8.CCIncludePath2: as above
  group App
    ../App/: app.c app.h define.h
  group Hal/inc
    ../Hal/inc/: adc.h bk2425.h debug.h key.h led.h light_blink.h lis3dh_driver.h mems_queue.h spi.h timer.h
  group Hal/src
    ../Hal/src/: adc.c bk2425.c debug.c key.c led.c light_blink.c lis3dh_driver.c mems_queue.c spi.c timer.c
  group Main
    ../Main/: main.c stm8s_conf.h stm8s_it.c stm8s_it.h
  group StdPeriph_Drivers
    ../../../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_adc2.c stm8s_awu.c stm8s_beep.c stm8s_can.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_tim5.c stm8s_tim6.c stm8s_uart1.c stm8s_uart2.c stm8s_uart3.c stm8s_uart4.c stm8s_wwdg.c
